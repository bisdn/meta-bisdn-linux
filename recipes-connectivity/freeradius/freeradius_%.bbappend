# Disable radiusd service by default
SYSTEMD_AUTO_ENABLE:${PN} = "disable"

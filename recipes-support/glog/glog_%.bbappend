EXTRA_OECMAKE:append = " \
    -DWITH_PKGCONFIG=ON \
"

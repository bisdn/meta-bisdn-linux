# Copyright (C) 2018 Tobias Jungel <tobias.jungel@bisdn.de>
# Released under the MIT license (see COPYING.MIT for the terms)

require rofl-ofdpa.inc
SRCREV = "c9fa1342eddce817d991a990010351de93aa579a"

# Copyright (C) 2018 Tobias Jungel <tobias.jungel@bisdn.de>
# Released under the MIT license (see COPYING.MIT for the terms)

require rofl-ofdpa.inc
SRCREV = "5e28ec4a604b8066c9061ecee348df4860fc627d"

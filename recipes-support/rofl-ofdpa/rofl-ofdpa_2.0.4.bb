# Copyright (C) 2018 Tobias Jungel <tobias.jungel@bisdn.de>
# Released under the MIT license (see COPYING.MIT for the terms)

require rofl-ofdpa.inc
SRCREV = "0d3591410f5ada591fc8bd2df78b5b84dc0b0458"

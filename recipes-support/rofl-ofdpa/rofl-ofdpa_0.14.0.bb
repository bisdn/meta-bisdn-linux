# Copyright (C) 2018 Tobias Jungel <tobias.jungel@bisdn.de>
# Released under the MIT license (see COPYING.MIT for the terms)

require rofl-ofdpa.inc
SRCREV = "9937418cad78cd88aaeca2fc7265fadd7d4c408b"

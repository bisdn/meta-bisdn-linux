# Copyright (C) 2018 Tobias Jungel <tobias.jungel@bisdn.de>
# Released under the MIT license (see COPYING.MIT for the terms)

require rofl-ofdpa.inc
SRCREV = "374d1e4dd1ded7d305285b0a5f314b3c31328c53"

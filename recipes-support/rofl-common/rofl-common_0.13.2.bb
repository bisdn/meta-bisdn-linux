# Copyright (C) 2018 Tobias Jungel <tobias.jungel@bisdn.de>
# Released under the MIT license (see COPYING.MIT for the terms)

require rofl-common.inc
SRCREV = "f1abe0a59b653ac06c33767b7aea15fc67639ee9"

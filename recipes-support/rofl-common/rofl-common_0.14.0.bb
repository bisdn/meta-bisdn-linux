# Copyright (C) 2018 Tobias Jungel <tobias.jungel@bisdn.de>
# Released under the MIT license (see COPYING.MIT for the terms)

require rofl-common.inc
SRCREV = "f985ce3120a17d4729601e8640755ed1b14e0f90"

# Copyright (C) 2018 Tobias Jungel <tobias.jungel@bisdn.de>
# Released under the MIT license (see COPYING.MIT for the terms)

require rofl-common.inc
SRCREV = "2a4ea705af2bb0cc27f558e9e6fbd67573727208"

# Copyright (C) 2018 Tobias Jungel <tobias.jungel@bisdn.de>
# Released under the MIT license (see COPYING.MIT for the terms)

require rofl-common.inc
SRCREV = "81f6ab0cfea15f16627aa8659e784c709e57ebea"

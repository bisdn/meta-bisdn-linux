# Copyright (C) 2018 Tobias Jungel <tobias.jungel@bisdn.de>
# Released under the MIT license (see COPYING.MIT for the terms)

require rofl-common.inc
SRCREV = "bab42cdd2cbd972f51efba961838ce482e1858b7"

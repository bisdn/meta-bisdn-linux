FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://platform-x86-64-accton-csp7551-r0-init.sh \
"

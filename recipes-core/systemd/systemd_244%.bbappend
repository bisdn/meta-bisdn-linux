require systemd.inc

SRC_URI += " \
    file://244/0001-v245-backport-add-vlan-protocol-parameter-for-bridge.patch \
    file://244/0001-v249-network-bridge-fix-applying-vlan-protocol.patch \
"

FILESEXTRAPATHS:append := "${THISDIR}/${BPN}:"

SRC_URI:append = " \
           file://0001-disable-UPB_LINKARR.patch \
"

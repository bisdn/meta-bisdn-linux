# Upstream-Status: unsubmitted
#
# pkg_resources.DistributionNotFound: The 'charset-normalizer~=2.0.0; python_version >= "3"' distribution was not found and is required by requests
RDEPENDS:${PN}:append = " python3-charset-normalizer"

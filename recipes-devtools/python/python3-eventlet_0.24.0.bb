DESCRIPTION = "Highly concurrent networking library"
HOMEPAGE = "http://pypi.python.org/pypi/eventlet"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=56472ad6de4caf50e05332a34b66e778"

SRC_URI[md5sum] = "40acca39e1da2a79e983a696b9b390a3"
SRC_URI[sha256sum] = "4c247db031ea374128e8c75a40fe5402c611e9a4798b9f90f095001192f22364"

inherit setuptools3 pypi

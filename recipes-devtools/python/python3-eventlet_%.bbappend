RDEPENDS:${PN} += "${PYTHON_PN}-monotonic ${PYTHON_PN}-dnspython"

# Upstream-Status: unsubmitted
#
# pkg_resources.DistributionNotFound: The 'sortedcontainers' distribution was not found and is required by ovs
RDEPENDS:${PN}:append = " python3-sortedcontainers"

# Upstream-Status: submitted [https://lists.yoctoproject.org/g/meta-virtualization/topic/91748148]
RDEPENDS:${PN}:remove = " python3-backports-functools-lru-cache"

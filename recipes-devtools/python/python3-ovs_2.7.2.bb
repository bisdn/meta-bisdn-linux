DESCRIPTION = "Open vSwitch library"
HOMEPAGE = "https://pypi.python.org/pypi/ovs"
SECTION = "devel/python"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/Apache-2.0;md5=89aea4e17d99a7cacdbeed46a0096b10"

SRC_URI[md5sum] = "8551ed58f4e5878db9a599e2d7792d98"
SRC_URI[sha256sum] = "24cc9e324b03ba8d5799f07edf6c8eef013d6cbf741707f42200b1674fd60928"

inherit setuptools3 pypi

CVE_STATUS[CVE-2026-111943] = "not-applicable-config: system certificates are updated"

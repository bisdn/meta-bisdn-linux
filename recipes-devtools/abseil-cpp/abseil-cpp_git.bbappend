FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-remove-neon-option-from-cross-compilation.patch"

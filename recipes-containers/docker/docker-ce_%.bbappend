# Disable docker service
SYSTEMD_AUTO_ENABLE_${PN} = "disable"

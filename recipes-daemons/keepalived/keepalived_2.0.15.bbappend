FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://2.0.15/0001-add-for-baseboxd-in-service-file.patch"

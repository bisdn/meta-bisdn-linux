FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://2.2.2/0001-add-for-baseboxd-in-service-file.patch"

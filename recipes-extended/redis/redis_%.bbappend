# Disable redis service
SYSTEMD_AUTO_ENABLE = "disable"
